Properties of the parts of a building model (IFC4)

# File
Description: Heizungsstellantrieb, 24 VDC oder 24 V AC, stromlos geschlossen, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H9100000, Heizungsstellantrieb, 24 VDC oder 24 V AC, stromlos geschlossen
In: Raum
Description: Elektrothermische Ventilstellantriebe für Heizungs-, Lüftungs- und Klimatechnik. Der Antrieb ist durch seine kompakte Bauweise sehr platzsparend. Durch die verjüngte Bauform, speziell im Befestigungsbereich der Mutter, ist die Montage leicht handhabbar. Das Befestigungskabel befindet sich nicht im Bereich der Befestigungsmutter. Dadurch ist die Wahrscheinlichkeit einer Berührung mit heizwasserführenden Vorrichtungen geringer. Da die Befestigungsmutter ein kontinuierliches Aufschrauben auf das Gewinde ermöglicht, ist, im Gegensatz zu Bajonett- und Schnappkupplungen, durch Zurückdrehen der Mutter um zwei bis drei Gewindegänge ein Öffnen des Ventils im spannungslosen Zustand möglich. Das Abführen von austretendem Wasser erfolgt über ein Ableitsystem. Durch ein spezielles Design konnte auf Dichtungen verzichtet werden. Die aktuelle Ventilstellung wird an 2 Positionen (oben und seitlich) angezeigt. Die Stellantriebe sind durch ihre Befestigung von M 30 x 1,5 und ihre Charakteristik (stromlos geschlossen) unter anderem passend für folgende Ventil- und Verteilerfabrikate: Beulco, Empur, Heimeier, Kamo, Oventrop, Purmo, SBK, SKV, Strawa, Taconova, Watts.; Classification: EC010193 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H9100000; ModelLabel: ZBOOA-040.100; GlobalTradeItemNumber: 4050528046598; ProductURL: https://alre.de/produkt_H9100000
Pset_Specification - NominalLength: 0.057 m; NominalWidth: 0.039 m; NominalDepth: 0.039 m; NetWeight: 0.086
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 39; Ausführung: mit Wachs gefüllt; Funktion: spannungslos geschlossen (NC); Höhe: 39; Nennleistung: 3; Länge: 39; Umgebungstemperatur: 0; Schutzart (IP): IP42; Anschluss an Ventil: M30 x 1,5; Hublänge: 3; Mit Standanzeiger: yes; Max. elektrische Leistungsaufnahme: 70; Netzspannung: 24 V AC/DC; ETIM-Klasse: EC010193; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H9100000.pdf
